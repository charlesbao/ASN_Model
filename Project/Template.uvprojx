# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Libraries\CMSIS\Device\Include;..\Libraries\CMSIS\Include;..\Libraries\StdPeriphDriver\inc;..\HardWare\delay;..\HardWare\sys;..\App;..\HardWare
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/: stm32f4xx_it.c
    ../Libraries/CMSIS/Device/Source/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/Source/arm/: startup_stm32f40_41xxx.s
  group StdPeriphDriver
    ../Libraries/StdPeriphDriver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group HardWare
    ../HardWare/delay/: delay.c
    ../HardWare/sys/: sys.c
    ../HardWare/: DAC8563.c
  group App
    ../App/: main_RK4.c
